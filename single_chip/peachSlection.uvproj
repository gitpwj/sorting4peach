# Keil uVision project peachSlection.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: peachSlection +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 peach.c
